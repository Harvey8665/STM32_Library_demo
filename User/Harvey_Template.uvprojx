# Keil uVision project Harvey_Template.uvprojx, settings and files
target Harvey (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Harvey_Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Core;..\FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Hardware\OLED;..\Hardware\ADC;..\Hardware\CCD;..\Hardware\KEY;..\Hardware\LED;..\Hardware\Motor;..\Hardware\TIM;..\Hardware\MPU6050;..\Hardware\IIC
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c 工程说明.txt
  group Hardware
    ../Hardware/TIM/: Tim.c
    ../Hardware/OLED/: oled.c
    ../Hardware/ADC/: adc.c
    ../Hardware/CCD/: ccd.c
    ../Hardware/IIC/: iic.c
    ../Hardware/MPU6050/: mpu6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Hardware/Motor/: Motor.c
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
